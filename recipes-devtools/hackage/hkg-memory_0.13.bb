DESCRIPTION = "Chunk of memory, polymorphic byte array management and manipulation."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=26e46726d1f288b6a8d3cd9ec8901ed3"

inherit hackage

SRC_URI[md5sum] = "b4ba26490e251b7197434f081a1db538"
SRC_URI[sha256sum] = "dc73602573eaed85b1887f07057151c7de63f559ef90a10297c363d9b120870a"
