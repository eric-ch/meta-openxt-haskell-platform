DESCRIPTION = "A library wrapping Prelude/Data.List functions that can throw exceptions, such as head and !!."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f5138d63fd9e7ecca79f04796e43bda4"

inherit hackage

SRC_URI[md5sum] = "a90d4088b638fa9d3e9c29696ada032f"
SRC_URI[sha256sum] = "d0319ea7b55947e70092f0256aa9f9d2496a93b0e2a0887c0f8eaa0d7fb9b6c9"
