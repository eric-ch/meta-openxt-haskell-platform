DESCRIPTION = "Haskell 98 phantom types to avoid unsafely passing dummy arguments."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6642f8d529de7903fd72440c2a7d230f"

inherit hackage

SRC_URI[md5sum] = "1567bce77034a9bb0893b96141a42e9a"
SRC_URI[sha256sum] = "e415d83329dba6c6b604cdf7ab331d321fa62d396f15e79439caa58279d6b77c"
