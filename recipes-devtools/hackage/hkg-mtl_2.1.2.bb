DESCRIPTION = "Monad classes using functional dependencies, with instances for various monad transformers, inspired by the paper Functional Programming with Overloading and Higher-Order Polymorphism, by Mark P Jones, in Advanced School of Functional Programming, 1995"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=315290737f6293f698ed37113aa1226d"

inherit hackage

SRC_URI[md5sum] = "943c110524d96126bfa0e61f7df1ebcd"
SRC_URI[sha256sum] = "8c775764333420a4391823f9cb9b640306a262552280ea9bbdd2ca11194a8bef"
