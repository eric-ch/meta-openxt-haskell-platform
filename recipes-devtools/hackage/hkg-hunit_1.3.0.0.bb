DESCRIPTION = "HUnit is a unit testing framework for Haskell, inspired by the JUnit tool for Java, see: http://www.junit.org."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4d036bff24e7f9e1a7a9012fbe91bb35"

HPN = "HUnit"
inherit hackage

SRC_URI[md5sum] = "9780a1e60cb66d4d49d576b657caa7ef"
SRC_URI[sha256sum] = "e130db953a2310d2c256a3923af0250be6ea19317f7d369b56d48f84cf96a55c"
