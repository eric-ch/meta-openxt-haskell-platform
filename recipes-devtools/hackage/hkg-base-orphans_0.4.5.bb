DESCRIPTION = "Base-Orphans defines orphan instances that mimic instances available in later versions of base to a wider (older) range of compilers."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7a79588be8b28a195edfbfaa84d82ded"

inherit hackage

SRC_URI[md5sum] = "0aa9f98b40179c0652e3757ddee3b30b"
SRC_URI[sha256sum] = "16b70764247f1545b76c51b1d93dfe98dc78076a710db777e213d61690053da7"
