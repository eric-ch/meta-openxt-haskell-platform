DESCRIPTION = "This package provides various primitive memory-related operations."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=be0b31f4d3a51d26d9983b09dc5cf70a"

inherit hackage

SRC_URI[md5sum] = "05d8583c20761ff88bd5959bc0f11817"
SRC_URI[sha256sum] = "93731fa72eaf74e8e83453f080828e18cec9fbc82bee91b49ba8b61c043d38c8"
