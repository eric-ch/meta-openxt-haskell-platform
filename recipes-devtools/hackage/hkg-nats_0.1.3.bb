DESCRIPTION = "Natural numbers."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b2729ba2123001e5560d64a76c01025f"

inherit hackage

SRC_URI[md5sum] = "3f666e4952ce781d3fda8d8635bce746"
SRC_URI[sha256sum] = "bf7720677f18f450031efde9199655e6fe90f757cb5e711b7069602cdfe607ce"
