DESCRIPTION = "This library provides monad morphism utilities, most commonly used for manipulating monad transformer stacks."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=99f9cc4a08ce3dc564ee0a753a79f4da"

inherit hackage

SRC_URI[md5sum] = "e8ebd20afb7394def1a04553888f430e"
SRC_URI[sha256sum] = "22e3665b4c86bf28cb4e836da91f586294d74d1cf1c18db364dcf568eba7bf4c"
