DESCRIPTION = "An efficient packed, immutable Unicode text type (both strict and lazy), with a powerful loop fusion optimization framework."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3137a2b6a6df0a4fab97e00be8dff1a2"

inherit hackage

SRC_URI[md5sum] = "caf11c87fb96259dd165e45e484ade7d"
SRC_URI[sha256sum] = "31465106360a7d7e214d96f1d1b4303a113ffce1bde44a4e614053a1e5072df9"
