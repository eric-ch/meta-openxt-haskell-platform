DESCRIPTION = "A binary serialization library, similar to binary, that introduces an isolate primitive for parser isolation, and labeled blocks for better error messages."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5ec64b8b2cb5d58bfa9e4662374b9108"

inherit hackage

SRC_URI[md5sum] = "139ac40880440d59fc94e9aacfb0c467"
SRC_URI[sha256sum] = "df047216179ba3817134e32c73ef9e3b5dddbd4efff604f50ca0ca0c93753097"
