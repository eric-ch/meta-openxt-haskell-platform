SUMMARY = "A UTF8 layer for IO and Strings."
DESCRIPTION = "The utf8-string package provides operations for encoding UTF8 strings to Word8 lists and back, and for reading and writing UTF8 without truncation."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8061b32e50a7a7433f0c7bd9f431ca96"

inherit hackage

SRC_URI[md5sum] = "fe24e26bd4b09731af66ef27b18b5177"
SRC_URI[sha256sum] = "fb0b9e3acbe0605bcd1c63e51f290a7bbbe6628dfa3294ff453e4235fbaef140"
