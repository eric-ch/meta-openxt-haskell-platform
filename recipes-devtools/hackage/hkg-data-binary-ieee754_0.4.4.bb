DESCRIPTION = "Parser/Serialiser for IEEE-754 Float and Decimal values to/from raw octets."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://License.txt;md5=ef44aa0bc0c7e388835dcf37047c3bc3"

inherit hackage

SRC_URI[md5sum] = "1a912f3d5b7ad6e984d5ab3c09f290de"
SRC_URI[sha256sum] = "59975abed8f4caa602f0780c10a9b2493479e6feb71ad189bb10c3ac5678df0a"
